Commit message: Height hardcode constraints removed

File: robotiq_85/robotiq_85.urdf (robot description, URDF)
Before this commit: robot robotiq_arg2f_85_model, 15 links, 14 joints
Joints:
- joint x_axis: origin (none) -> xyz=0 0 0 rpy=0 0 0
